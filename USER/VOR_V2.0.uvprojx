# Keil uVision project VOR_V2.0.uvprojx, settings and files
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: template +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=550  --diag_suppress=188  --diag_suppress=167  --diag_suppress=668 --diag_suppress=1035 --diag_suppress=1295 --diag_suppress=1
  c include: ..\FREERTOS\source\include;..\CORE;..\USER;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\TOUCH;..\INTERFACE\LVGL\lvgl;..\INTERFACE\LVGL\lvgl\lsrc;..\INTERFACE\LVGL\lvgl\src\core;..\INTERFACE\LVGL\lvgl\src\draw;..\INTERFACE\LVGL\lvgl\src\font;..\INTERFACE\LVGL\lvgl\src\hal;..\INTERFACE\LVGL\lvgl\src\misc;..\INTERFACE\LVGL\lvgl\src\theme;..\INTERFACE\LVGL\lvgl\src\widgets;..\INTERFACE\LVGL\lvgl\src\extra;..\INTERFACE\LVGL\lvgl\src\extra\layouts;..\INTERFACE\LVGL\lvgl\src\extra\layout\flex;..\INTERFACE\LVGL\lv_port;..\INTERFACE\LVGL\lvgl\src\extra\layouts\flex;..\INTERFACE\LVGL\lvgl\src\extra\layouts\grid;..\INTERFACE\LVGL\lvgl\src\extra\libs;..\INTERFACE\LVGL\lvgl\src\extra\others;..\INTERFACE\LVGL\lvgl\src\extra\themes;..\INTERFACE\LVGL\lvgl\src\extra\widgets;..\INTERFACE\LVGL\lvgl\src\extra\themes\basic;..\INTERFACE\LVGL\lvgl\src\extra\libs\qrcode;..\HARDWARE\SYSTEM\sys;..\HARDWARE\SYSTEM\delay;..\HARDWARE\SYSTEM\usart;..\FREERTOS;..\FREERTOS\source\portable\rvds\ARM_CM4F;..\INTERFACE\LVGL;..\INTERFACE\UI;..\INTERFACE\UI\control;..\commuication\USB\USB_APP;..\commuication\USB\STM32_USB_Device_Library\Class\cdc\inc;..\commuication\USB\STM32_USB_OTG_Driver\inc;..\commuication\USB\STM32_USB_Device_Library\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1fff0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c CCM_memory_Value.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: ft5206.c ctiic.c
    ../HARDWARE/SLAVE/: Slave1_IO.c Slave1_Timer.c
    ../HARDWARE/USART/: USART1.c USART3.c USART5.c USART6.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/IR_Sense/: IR.c
    ../HARDWARE/INC/: INC_CTRl.c
    ../HARDWARE/FAN/: FAN.c
    ../HARDWARE/c610/: C610.c
  group SYSTEM
    ../HARDWARE/SYSTEM/delay/: delay.c
    ../HARDWARE/SYSTEM/sys/: sys.c
    ../HARDWARE/SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_wwdg.c
  group FREERTOS
    ../FREERTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c timers.c tasks.c
    ../FREERTOS/source/portable/memmang/: heap_4.c
    ../FREERTOS/source/portable/rvds/ARM_CM4F/: port.c
  group lv_port
    ../INTERFACE/LVGL/lv_port/: lv_port_disp.c lv_port_indev.c
  group lv_core
    ../INTERFACE/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lv_draw
    ../INTERFACE/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../INTERFACE/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_transform.c lv_draw_sw_layer.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lv_extra
    ../HARDWARE/c610/: pid.c
    ../INTERFACE/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../INTERFACE/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../INTERFACE/LVGL/lvgl/src/extra/: lv_extra.c
    ../INTERFACE/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../INTERFACE/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../INTERFACE/LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../INTERFACE/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
  group lv_font
    ../INTERFACE/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lv_hal
    ../INTERFACE/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../INTERFACE/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_widgets
    ../INTERFACE/LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../INTERFACE/LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
  group control
    ../INTERFACE/UI/control/: control.c control_base.c task_control.c control_Hardware_API.c control_CONT.h control_VOR.c control_CONT.c control_OVAR.c control_VHIT.c control_TC.c
  group other
    ../INTERFACE/UI/other/: list.c system_function.c meassage_center.c
  group Task_Manager
    ../INTERFACE/UI/Task/: task_stroage.c task_manager.c
  group UI_Component
    ../INTERFACE/UI/UI_Component/: UI_Btn.c UI_Dropdown.c UI_ListBox.c UI_SpinBox.c
  group UI_page
    ../INTERFACE/UI/UI_page/: page1.c PageManagment.c Page_Maintain.c
  group UI_parameter
    ../INTERFACE/UI/UI_Parameter/: UI_Parameter_Cont.c UI_Parameter_Set.c UI_Parameter_Vor.c UI_Parameter_Ovar.c UI_Parameter_VHIT.c UI_Parameter_TC.c
  group implement
    ../implement/: Slave_Vor_Ctrl.c Slave_OVAR_Ctrl.c Slave_Cont_Ctrl.c Slave_Inc_Ctrl.c motor_para_cal.c Slave_VHIT_Ctrl.c Slave_TC_Ctrl.c
  group communication
    ../commuication/BLUETOOTH/: BlueTooth.c
    ../commuication/: communication.c communication_API.c rk3588_uart.c
    ../commuication/mpu/: jy60.c
  group USB
    ../commuication/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../commuication/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../commuication/USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../commuication/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
target debug (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: template +hex
  AfterMake: "F:\A0 冯梓安\南科大电机 项目3 vor伺服\伺服电机项目3\vor-pjt\template\hex.bat"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=550  --diag_suppress=188  --diag_suppress=167  --diag_suppress=668 --diag_suppress=1035
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\TIMER;..\HARDWARE\SRAM;..\lvgl;..\INTERFACE\LVGL\lvgl\lsrc;..\INTERFACE\LVGL\lvgl\src\core;..\INTERFACE\LVGL\lvgl\src\draw;..\INTERFACE\LVGL\lvgl\src\font;..\INTERFACE\LVGL\lvgl\src\hal;..\INTERFACE\LVGL\lvgl\src\misc;..\INTERFACE\LVGL\lvgl\src\theme;..\INTERFACE\LVGL\lvgl\src\widgets;..\INTERFACE\LVGL\lvgl\src\extra;..\INTERFACE\LVGL\lvgl\src\extra\layouts;..\INTERFACE\LVGL\lvgl\src\extra\layout\flex;..\lv_port;..\INTERFACE\LVGL\lvgl\src\extra\layouts\flex;..\INTERFACE\LVGL\lvgl\src\extra\layouts\grid;..\INTERFACE\LVGL\lvgl\src\extra\libs;..\INTERFACE\LVGL\lvgl\src\extra\others;..\INTERFACE\LVGL\lvgl\src\extra\themes;..\INTERFACE\LVGL\lvgl\src\extra\widgets;..\INTERFACE\LVGL\lvgl\src\extra\themes\basic;..\;..\GUI;..\Motor;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\INTERFACE\LVGL\lvgl\src\extra\libs\qrcode;..\DataScope_DP;..\GUI;..\HARDWARE\WWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT5: ROM 0x8050000 size 0x150000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
