# Keil uVision project PJ3_test.uvprojx, settings and files
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HARDWARE_TEST,USE_USB_OTG_FS
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=550  --diag_suppress=188  --diag_suppress=167  --diag_suppress=668 --diag_suppress=1035,1
  c include: ..\FREERTOS\source\include;..\CORE;..\USER;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\TOUCH;..\INTERFACE\LVGL\lvgl;..\INTERFACE\LVGL\lvgl\lsrc;..\INTERFACE\LVGL\lvgl\src\core;..\INTERFACE\LVGL\lvgl\src\draw;..\INTERFACE\LVGL\lvgl\src\font;..\INTERFACE\LVGL\lvgl\src\hal;..\INTERFACE\LVGL\lvgl\src\misc;..\INTERFACE\LVGL\lvgl\src\theme;..\INTERFACE\LVGL\lvgl\src\widgets;..\INTERFACE\LVGL\lvgl\src\extra;..\INTERFACE\LVGL\lvgl\src\extra\layouts;..\INTERFACE\LVGL\lvgl\src\extra\layout\flex;..\INTERFACE\LVGL\lv_port;..\INTERFACE\LVGL\lvgl\src\extra\layouts\flex;..\INTERFACE\LVGL\lvgl\src\extra\layouts\grid;..\INTERFACE\LVGL\lvgl\src\extra\libs;..\INTERFACE\LVGL\lvgl\src\extra\others;..\INTERFACE\LVGL\lvgl\src\extra\themes;..\INTERFACE\LVGL\lvgl\src\extra\widgets;..\INTERFACE\LVGL\lvgl\src\extra\themes\basic;..\INTERFACE\LVGL\lvgl\src\extra\libs\qrcode;..\HARDWARE\SYSTEM\sys;..\HARDWARE\SYSTEM\delay;..\HARDWARE\SYSTEM\usart;..\FREERTOS;..\FREERTOS\source\portable\rvds\ARM_CM4F;..\INTERFACE\LVGL;..\INTERFACE\UI;..\INTERFACE\UI\control;..\commuication\USB\USB_APP;..\commuication\USB\STM32_USB_Device_Library\Class\cdc\inc;..\commuication\USB\STM32_USB_OTG_Driver\inc;..\commuication\USB\STM32_USB_Device_Library\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c CCM_memory_Value.c
    ./hard_test/: test_main.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: ft5206.c ctiic.c
    ../HARDWARE/SLAVE/: Slave1_IO.c Slave1_Timer.c
    ../HARDWARE/USART/: USART3.c USART5.c USART1.c
    ../HARDWARE/INC/: INC_CTRl.c
    ../HARDWARE/IR_Sense/: IR.c
  group SYSTEM
    ../HARDWARE/SYSTEM/delay/: delay.c
    ../HARDWARE/SYSTEM/sys/: sys.c
    ../HARDWARE/SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_wwdg.c
  group FREERTOS
    ../FREERTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c timers.c tasks.c
    ../FREERTOS/source/portable/memmang/: heap_4.c
    ../FREERTOS/source/portable/rvds/ARM_CM4F/: port.c
  group implement
    ../implement/: motor_para_cal.c Slave_Inc_Ctrl.c Slave_Vor_Ctrl.c Slave_Cont_Ctrl.c Slave_OVAR_Ctrl.c Slave_Zero_ctrl.c
  group cummunication
    ../commuication/: communication.c communication_API.c
    ../commuication/mpu/: jy60.c
    ../commuication/BLUETOOTH/: BlueTooth.c
    ../INTERFACE/UI/other/: meassage_center.c
  group usb
    ../commuication/USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../commuication/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../commuication/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../commuication/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group other
    ../INTERFACE/UI/other/: system_function.c
target debug (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: template +hex
  AfterMake: "F:\A0 冯梓安\南科大电机 项目3 vor伺服\伺服电机项目3\vor-pjt\template\hex.bat"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=550  --diag_suppress=188  --diag_suppress=167  --diag_suppress=668 --diag_suppress=1035
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\TIMER;..\HARDWARE\SRAM;..\lvgl;..\INTERFACE\LVGL\lvgl\lsrc;..\INTERFACE\LVGL\lvgl\src\core;..\INTERFACE\LVGL\lvgl\src\draw;..\INTERFACE\LVGL\lvgl\src\font;..\INTERFACE\LVGL\lvgl\src\hal;..\INTERFACE\LVGL\lvgl\src\misc;..\INTERFACE\LVGL\lvgl\src\theme;..\INTERFACE\LVGL\lvgl\src\widgets;..\INTERFACE\LVGL\lvgl\src\extra;..\INTERFACE\LVGL\lvgl\src\extra\layouts;..\INTERFACE\LVGL\lvgl\src\extra\layout\flex;..\lv_port;..\INTERFACE\LVGL\lvgl\src\extra\layouts\flex;..\INTERFACE\LVGL\lvgl\src\extra\layouts\grid;..\INTERFACE\LVGL\lvgl\src\extra\libs;..\INTERFACE\LVGL\lvgl\src\extra\others;..\INTERFACE\LVGL\lvgl\src\extra\themes;..\INTERFACE\LVGL\lvgl\src\extra\widgets;..\INTERFACE\LVGL\lvgl\src\extra\themes\basic;..\;..\GUI;..\Motor;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\INTERFACE\LVGL\lvgl\src\extra\libs\qrcode;..\DataScope_DP;..\GUI;..\HARDWARE\WWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT5: ROM 0x8050000 size 0x150000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
